# Repository alexth4ef9/fancontroller-hardware

File README.md:

# fancontroller-hardware
fan controller addon board for OLIMEXINO-STM32F3

## Features:

* Controls 3 4-pin PWM fans. One fan output can be changed to a high power PWM pump control-
* Voltage/current measurement of the fans.
* 4 STEMMA QT compatible connectors, usable for temperature sensors.
* 2 Analog inputs.
* SPI FLASH 64Mb 

## Variants:

* 3 fans: populate J7, J9, J10
* 2 fans, 1 pump: populate J8, J9, J10 and add R2

## Errata

|revision|errata|fixed revision|
|--------|------|--------------|
| 1      | D31/32 are swapped on U3 | 2 |
| 1/2    | GND and +3V3 are swapped on J1/2/3/4 | 3 |

## Modification to OLIMEXINO-STM32F3:

Connect VIN on PLATFORM1 to PWR1 pin 2

## License

Copyright alexth4e9f 2021.

This source describes Open Hardware and is licensed under the CERN-OHL-S v2.

You may redistribute and modify this source and make products using it under the terms of the CERN-OHL-S v2 (https://ohwr.org/cern_ohl_s_v2.txt).

This source is distributed WITHOUT ANY EXPRESS OR IMPLIED WARRANTY, INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A PARTICULAR PURPOSE. Please see the CERN-OHL-S v2 for applicable conditions.

## KiCad design fan_controller.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C10, C11, C13: 100nF; C_0603_1608Metric
C8: 10uF 6.3V; C_0603_1608Metric
C12, C14, C15: 4.7uF 35V 0805; C_0805_2012Metric
D1: APTD1608LCGCK; LED_0603_1608Metric
D2: APTD1608LSURCK; LED_0603_1608Metric
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
GPIO1: DNI_TSW-108-07-T-D; BH16S
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2
J1, J2, J3, J4: SM04B-SRSS-TB; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J5, J6: DNI_53047-0310; Molex_PicoBlade_53047-0310_1x03_P1.25mm_Vertical
J7, J9, J10: DNI_47053-1000; FanPinHeader_1x04_P2.54mm_Vertical
J8: DNI_26-01-3115; Molex_Mini-Fit_Jr_5569-04A2_2x02_P4.20mm_Horizontal
J11: DNI_26-01-3114; Molex_Mini-Fit_Jr_5569-02A2_2x01_P4.20mm_Horizontal
PLATFORM1: DNI_2xTSW-106-07-T-S+2xTSW-108-07-T-S; ARDUINO-STM32-PLATFORM
R1, R3, R4: WSL2512R1000DEA; R_2512_6332Metric
R2: DNI_WSL2512R1000DEA; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R5, R6, R7, R8, R9, R10: 10 1%; R_0603_1608Metric
R11, R14, R16, R18, R20, R21, R27, R28, R36: 10k; R_0603_1608Metric
R12, R13, R15, R17, R19, R22, R23, R24: 4k7; R_0603_1608Metric
R25, R26, R37, R38, R39: 2k2; R_0603_1608Metric
R29, R30, R31, R32: 10k 1%; R_0603_1608Metric
R33: 22; R_0603_1608Metric
R34, R35: 10; R_0603_1608Metric
R40: 1k4; R_0603_1608Metric
R41: 1k5; R_0603_1608Metric
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_D1.0mm
U1: PCA9546APW; TSSOP-16_4.4x5mm_P0.65mm
U2: INA3221; Texas_RGV_S-PVQFN-N16_EP2.1x2.1mm
U3: W25Q64JVSSIM; SOIC-8_5.23x5.23mm_P1.27mm
U4: OPA2313QDGKRQ1; VSSOP-8_3.0x3.0mm_P0.65mm
U5: SN74AHCT125PW; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3V3: C5.1, C6.1, C7.1, C14.1, J1.2, J2.2, J3.1, J4.2, PLATFORM1.2 (3.3V), R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.2, R26.2, R27.1, R28.1, R33.2, R36.1, R37.1, R38.1, R39.1, U1.16 (VDD), U2.4 (VS), U2.16 (VPU), U3.8 (VCC), U5.13
+5V: C13.1, PLATFORM1.3 (5.0V), U5.14 (VCC)
+12V: C12.1, C15.1, J5.2, J6.2, J11.1, PLATFORM1.6 (VIN), R1.1, R2.1, R3.1, R4.1, R5.2, R7.2, R9.2
/A0: C10.1, PLATFORM1.7 (A0), R34.1
/A1: C11.1, PLATFORM1.8 (A1), R35.1
/D4: PLATFORM1.17 (D4), R41.1
/D5: PLATFORM1.18 (D5), R26.1, U2.6 (SCL)
/D7: PLATFORM1.20 (D7), U1.14 (SCL)
/D8: PLATFORM1.21 (D8), U1.15 (SDA)
/D9: PLATFORM1.22 (D9), R25.1, U2.7 (SDA)
/D10: J9.3, PLATFORM1.23 (D10), R38.2
/D11: PLATFORM1.24 (D11), R40.1
/D12: J7.3, J8.3, PLATFORM1.25 (D12), R37.2
/D26: C4.1, GPIO1.4, R11.2, U1.3 (RESET)
/D27: GPIO1.5, J10.3, R39.2
/D28: GPIO1.6, R36.2, U5.1, U5.4, U5.10
/D31: GPIO1.9, R20.2, U3.1 (~CS)
/D32: GPIO1.10, U3.6 (CLK)
/D33: GPIO1.11, U3.2 (DO(IO1))
/D34: GPIO1.12, U3.5 (DI(IO0))
/D35: GPIO1.13, U5.2
/D36: GPIO1.14, U5.5
/D37: GPIO1.15, U5.9
/PWM0: J7.4, J8.4, U5.3
/PWM1: J9.4, U5.6
/PWM2: J10.4, U5.8
/PWR0: J7.2, J8.2, R1.2, R2.2, R6.2
/PWR1: J9.2, R3.2, R8.2
/PWR2: J10.2, R4.2, R10.2
GND: C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D1.1 (K), D2.1 (K), J1.1, J2.1, J3.2, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.2, PLATFORM1.5 (GND), R31.2, R32.2, U1.1 (A0), U1.2 (A1), U1.8 (VSS), U1.13 (A2), U2.3 (GND), U2.5 (A0), U2.17 (EP), U3.4 (GND), U4.4 (V-), U5.7 (GND), U5.12
unnamed: C1.1, R5.1, U2.12 (IN+1)
unnamed: C1.2, R6.1, U2.11 (IN-1)
unnamed: C2.1, R7.1, U2.15 (IN+2)
unnamed: C2.2, R8.1, U2.14 (IN-2)
unnamed: C3.1, R9.1, U2.2 (IN+3)
unnamed: C3.2, R10.1, U2.1 (IN-3)
unnamed: C8.2, C9.1, R33.1, U4.8 (V+)
unnamed: D1.2 (A), R40.2
unnamed: D2.2 (A), R41.2
unnamed: J1.3, R13.2, U1.4 (SD0)
unnamed: J1.4, R12.2, U1.5 (SC0)
unnamed: J2.3, R17.2, U1.6 (SD1)
unnamed: J2.4, R15.2, U1.7 (SC1)
unnamed: J3.3, R22.2, U1.9 (SD2)
unnamed: J3.4, R19.2, U1.10 (SC2)
unnamed: J4.3, R24.2, U1.11 (SD3)
unnamed: J4.4, R23.2, U1.12 (SC3)
unnamed: J5.3, R29.2
unnamed: J6.3, R30.2
unnamed: R14.2, TP1.1, U2.10 (PV)
unnamed: R16.2, TP2.1, U2.9 (CRITICAL)
unnamed: R18.2, TP3.1, U2.8 (WARNING)
unnamed: R21.2, TP4.1, U2.13 (TC)
unnamed: R27.2, U3.3 (IO2)
unnamed: R28.2, U3.7 (IO3)
unnamed: R29.1, R31.1, U4.3 (+)
unnamed: R30.1, R32.1, U4.5 (+)
unnamed: R34.2, U4.1, U4.2 (-)
unnamed: R35.2, U4.6 (-), U4.7

Notes on the sheet:
OLIMEXINO-STM32F3 modification: wire between VIN and PWR1 pin 2

Board: 4 copper layers, 68.5 x 53.3 mm, 86 parts (1 on the bottom side), 59 nets.

## Commit log

2021-10-31 add design files
2021-11-07 rev2: swap D31 and D32 at U3
2021-11-28 rev3: fix stemma qt pinout
2021-11-28 updated documentation

Notices in the files:
fan_controller.kicad_pcb:
licensed under CERN-OHL-S v2
